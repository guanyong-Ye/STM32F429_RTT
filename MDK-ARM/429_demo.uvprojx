# Keil uVision project 429_demo.uvprojx, settings and files
target 429_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 429_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\BSP;..\BSP\GPIO;..\BSP\KEY;..\BSP\TIMER;..\BSP\UART;..\BSP\TIM;..\rt-thread\bsp;..\rt-thread\components\finsh;..\rt-thread\include;..\rt-thread\include\libc;..\rt-thread\libcpu\arm\cortex-m4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group bsp
    ../BSP/: bsp.c
    ../BSP/GPIO/: bsp_gpio.c
    ../BSP/KEY/: bsp_key.c
    ../BSP/TIMER/: bsp_timer.c
    ../BSP/TIM/: bsp_tim.c
    ../BSP/UART/: bsp_uart.c
    ../Src/: math_calc.c
    ../rt-thread/bsp/: board.c rtconfig.h
  group rtt/shell
    ../rt-thread/components/finsh/: cmd.c msh.c shell.c
  group rtt/sources
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/port
    ../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
software components: CMSIS:CORE 5.3.0
